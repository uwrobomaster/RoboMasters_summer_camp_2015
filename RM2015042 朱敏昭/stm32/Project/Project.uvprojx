# Keil uVision project Project.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\inc;..\APP;..\BSP;..\Libraries\CMSIS;..\Libraries\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_it.c system.c data_transfer.c
  group BSP
    ../BSP/: ad.c can.c encoder.c key.c led.c pwm.c usart2.c motor.c
  group STM32_StdPeriph
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/: system_stm32f10x.c
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_exti.c
