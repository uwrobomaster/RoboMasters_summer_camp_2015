# Keil uVision project SetupBoard.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10x, ARM_MATH_CM3, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: .\Users;.\Users\FreeRTOS;.\Users\FreeRTOS\Source;.\Users\FreeRTOS\Source\include;.\Users\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\Users\Template
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Users
    ./Users/: main.c stm32f4xx_it.c Data.c
    ./Users/Template/: cpustate.c UI.c BSP.H
  group Drivers
    ./Users/Template/: CAN_driver.c Oled.c Afei_Bluetooth.c BSP.c
  group RTOS
    ./Users/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./Users/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Users/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
